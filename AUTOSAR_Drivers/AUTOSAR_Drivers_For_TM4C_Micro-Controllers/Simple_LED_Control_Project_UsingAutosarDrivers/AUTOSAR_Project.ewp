# IAR project AUTOSAR_Project.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: TM4C123GH6PM TexasInstruments TM4C123GH6PM
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: c.srec
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: App.c App.h Button.c Button.h Common_Macros.h Compiler.h cstartup_M.c Det.c Det.h Dio.c Dio.h Dio_cfg.h Dio_PBcfg.c Dio_PBcfg.h Dio_Registers.h Dio_Types.h Gpt.c Gpt.h Gpt_cfg.h Gpt_Irq.c Gpt_PBcfg.c Gpt_PBcfg.h Gpt_Registers.h Gpt_Types.h Led.c Led.h main.c Os.c Os.h OS_Registers.h Platform_Types.h Port.c Port.h Port_cfg.h Port_PBcfg.c Port_PBcfg.h Port_Registers.h Port_Types.h Std_Types.h
