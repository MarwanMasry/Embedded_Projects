# IAR project Complete_GPT_Autosar_Driver.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: TM4C123GH6PM TexasInstruments TM4C123GH6PM
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: c.srec
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: Common_Macros.h Compiler.h cstartup_M.c Det.c Det.h Gpt.c Gpt.h Gpt_cfg.h Gpt_Irq.c Gpt_ModuleTest.c Gpt_ModuleTest.h Gpt_PBcfg.c Gpt_PBcfg.h Gpt_Registers.h Gpt_Types.h main.c Platform_Types.h Std_Types.h tm4c123gh6pm_registers.h
