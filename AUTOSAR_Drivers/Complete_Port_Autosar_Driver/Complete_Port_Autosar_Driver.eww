<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\Complete_Port_Autosar_Driver.ewp</path>
  </project>
  <batchBuild/>
</workspace>


