# IAR project Complete_Dio_Autosar_Driver.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: TM4C123GH6PM TexasInstruments TM4C123GH6PM
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: c.srec
  ILINK.IlinkOutputFile: c.out
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: Common_Macros.h Compiler.h Det.c Det.h Dio.c Dio.h Dio_cfg.h Dio_ModuleTest.c Dio_ModuleTest.h Dio_PBcfg.c Dio_PBcfg.h Dio_Registers.h Dio_Types.h main.c Platform_Types.h Std_Types.h tm4c123gh6pm_registers.h
